# Repository ajay-paul/FPGA_Alarm

File README.md:

# FPGA_Alarm
 
Developed and implemented an alarm system using VHDL on a Nexys A7 FPGA board. Integrated a 4x4 Matrix keypad for user input. Employed Kicad to design a custom PCB for the project. The alarm system incorporated users to input a correct 4-digit password via the keypad, which was then displayed on a 7-segment display.

## KiCad design PCB_Desgin/Alaram_update.kicad_pcb

Board: 4 copper layers, 85.7 x 100.6 mm, 120 parts (0 on the bottom side), 83 nets.

Parts:
C1, C2: 10 uF; C_0201_0603Metric
C3: C5; C_0201_0603Metric
C4, C7: 1 uF; C_0201_0603Metric
C5, C6, C15, C16, C24: 0.1 uF; C_0201_0603Metric
C8, C9, C10, C11, C12, C13, C14: 22 uF; C_0201_0603Metric
C17, C33: 47uF; C_0201_0603Metric
C18, C20: 47 uF; C_0201_0603Metric
C19, C22, C32, C40, C41: 4.7 uF; C_0201_0603Metric
C21, C23, C25, C26, C27, C28, C29, C30, C31: 0.47 uF; C_0201_0603Metric
C34, C35: 4.7uF; C_0201_0603Metric
C36, C37, C38, C39: 0.47uF; C_0201_0603Metric
C42: 100 uF; C_0201_0603Metric
D1, D2, D3, D4, D5, D7: LED; LED_0201_0603Metric_Pad0.64x0.40mm_HandSolder
D9: LED_RBKG; LED_Avago_PLCC4_3.2x2.8mm_CW
J1: Barrel_Jack_Switch; BarrelJack_CUI_PJ-036AH-SMT_Horizontal
J2: XILINX_JTAG; PinHeader_2x07_P2.00mm_Vertical_SMD
L1, L2, L3: 2.2 uH; L_6.3x6.3_H3
Q1, Q2: DMN2041L; SOT-23
R1, R2, R3: 100K; R_0201_0603Metric
R4, R5, R6: 2.2K; R_0201_0603Metric
R7: 7.36K; R_0201_0603Metric
R8: 3.0K; R_0201_0603Metric
R9, R42: 680; R_0201_0603Metric
R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R39, R46, R47: 330; R_0201_0603Metric
R37, R38, R45: 4.75K; R_0201_0603Metric
R40, R41, R43, R44: 10K; R_0201_0603Metric
S1: B3FS_1010P; Panasonic_EVQPUL_EVQPUC
S2: CFG_RESET; Panasonic_EVQPUK_EVQPUB
S3: B3FS_1010P; Panasonic_EVQPUK_EVQPUB
SW1: SW_Push_Close; Panasonic_EVQPUL_EVQPUC
SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10: SW_Push_close; Panasonic_EVQPUL_EVQPUC
U1: TPS65581; HTSSOP-20-1EP_4.4x6.5mm_P0.65mm_EP3.4x6.5mm_Mask2.75x3.43mm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
U2: XC7S50-FTGB196; Xilinx_FTGB196
U3: CA56-12CGKWA
X1: DSC61XX; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm_HandSoldering

Connections:
+1V0: C10.2, C12.2, C14.2, C20.1, C22.1, C25.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C40.1, C41.1, C42.1, L2.1, R9.1, U2.D6 (VCCINT), U2.D8 (VCCINT), U2.E5 (VCCBRAM), U2.E7 (VCCINT), U2.E9 (VCCINT), U2.F6 (VCCINT), U2.G5 (VCCBRAM), U2.G9 (VCCINT), U2.H6 (VCCINT), U2.J5 (VCCBRAM), U2.J9 (VCCINT), U2.K6 (VCCINT), U2.K8 (VCCINT)
+1V8: C11.2, C13.2, C15.1, C18.1, C19.1, C21.1, C23.1, C26.1, L3.1, R8.1, U2.F8 (VCCADC_0), U2.F10 (VCCAUX), U2.H10 (VCCAUX), U2.K10 (VCCAUX), U2.L9 (VCCAUX)
+3.3V: R10.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1
+3V3: C8.2, C9.2, C17.1, C24.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, D1.2 (A), D7.1 (K), J2.2 (VREF), L1.1, R1.2, R7.1, R37.2, R38.2, R39.1, R40.1, R41.1, R43.1, R44.1, R45.1, U2.G13 (VCCO_14), U2.K13 (VCCO_14), U2.M7 (M0_0), U2.N6 (VCCO_0), U2.N7 (CFGBVS_0), U2.N8 (VCCO_0), U2.N13 (VCCO_14), X1.1 (OE), X1.4 (VCC)
+12V: C1.1, C2.1, C3.1, J1.1, R3.2, U1.1 (VIN), U1.2 (VIN)
/FPGA_JTGA/FPGA_DONE: Q2.1 (G), R39.2, U2.P9 (DONE_0)
/FPGA_JTGA/INIT_B: R37.1, U2.P8 (INIT_B_0)
/FPGA_JTGA/JTAG_TCK: J2.6 (TCK), R41.2, U2.A7 (TCK_0)
/FPGA_JTGA/JTAG_TDI: J2.10 (TDI), R44.2, U2.P6 (TDO_0)
/FPGA_JTGA/JTAG_TDO: J2.8 (TDO), R43.2, U2.P7 (TDI_0)
/FPGA_JTGA/JTAG_TMS: J2.4 (TMS), R40.2, U2.M6 (TMS_0)
/FPGA_JTGA/PROGRAM_B: R38.1, S2.1, S2.2, U2.L7 (PROGRAM_B_0)
/FPGA_key/SW3_R: R24.2, SW3.2 (B), U2.C3 (IO_L1N_T0_34)
/FPGA_key/SW4_R: R25.2, SW4.2 (B), U2.A4 (IO_L2P_T0_34)
/FPGA_key/SW5_R: R26.2, SW5.2 (B), U2.A3 (IO_L2N_T0_34)
/FPGA_key/SW6_R: R27.2, SW6.2 (B), U2.B3 (IO_L3P_T0_DQS_34)
/FPGA_key/SW7_R: R28.2, SW7.2 (B), U2.A2 (IO_L3N_T0_DQS_34)
/FPGA_key/SW8_R: R29.2, SW8.2 (B), U2.B5 (IO_L4P_T0_34)
/FPGA_key/SW9_R: SW9.2 (B), U2.G4 (IO_L12P_T1_MRCC_34)
/FPGA_key/SW10_R: R30.2, R31.2, SW10.2 (B), U2.H3 (IO_L13N_T2_MRCC_34)
/power/PG00D: Q1.1 (G), R1.1, U1.7 (PG)
/power/SW1: C7.1, L3.2, U1.4 (SW1)
/power/SW2: C6.1, L2.2, U1.19 (SW2)
/power/SW3: C5.1, L1.2, U1.15 (SW3)
GND: C1.2, C2.2, C3.2, C4.2, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D9.3 (K), J1.2, J2.1 (GND), J2.3 (GND), J2.5 (GND), J2.7 (GND), J2.9 (GND), J2.11 (GND), J2.13 (GND), Q1.2 (S), Q2.2 (S), S1.1, S1.2, S3.1, S3.2, SW1.1 (A), SW2.1 (A), SW3.1 (A), SW4.1 (A), SW5.1 (A), SW6.1 (A), SW7.1 (A), SW8.1 (A), SW9.1 (A), SW10.1 (A), U1.10 (GND), U1.21 (PAD), U2.A1 (GND), U2.A6 (GND), U2.A9 (GND), U2.A11 (GND), U2.A14 (GND), U2.B4 (GND), U2.B7 (GND), U2.B8 (VCCBATT_0), U2.B9 (GND), U2.C2 (GND)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
unnamed: D1.1 (K), R2.2
unnamed: D2.2 (A), R32.2
unnamed: D3.2 (A), R33.2
unnamed: D4.2 (A), R34.2
unnamed: D5.2 (A), R35.2
unnamed: D7.2 (A), R42.1
unnamed: D9.2 (BA), R47.2
unnamed: D9.4 (GA), R36.2
unnamed: D9.1 (RA), R46.2
unnamed: Q1.3 (D), R2.1
unnamed: Q2.3 (D), R42.2
unnamed: R10.2, SW1.2 (B), U2.B6 (IO_0_34)
unnamed: R23.2, SW2.2 (B), U2.D3 (IO_L1P_T0_34)
unnamed: R3.1, U1.8 (EN1), U1.13 (EN3), U1.17 (EN2)
unnamed: R4.2, U1.5 (PGND1)
unnamed: R6.2, U1.18 (PGND2)
unnamed: R5.2, U1.16 (PGND3)
unnamed: C7.2, U1.3 (VBST1)
unnamed: C6.2, U1.20 (VBST2)
unnamed: C5.2, U1.14 (VBST3)
unnamed: R4.1, R8.2, U1.9 (VFB1)
unnamed: R6.1, R9.2, U1.11 (VFB2)
unnamed: R5.1, R7.2, U1.12 (VFB3)
unnamed: C4.1, U1.6 (VREG5)
unnamed: R15.2, U2.E11 (IO_0_14)
unnamed: R17.2, U2.B12 (IO_L1N_T0_D01_DIN_14)
unnamed: R16.2, U2.B11 (IO_L1P_T0_D00_MOSI_14)
unnamed: R19.2, U2.C10 (IO_L2N_T0_D03_14)
unnamed: R18.2, U2.D10 (IO_L2P_T0_D02_14)
unnamed: R21.2, U2.A10 (IO_L3N_T0_DQS_EMCCLK_14)
unnamed: R20.2, U2.B10 (IO_L3P_T0_DQS_PUDC_B_14)
unnamed: R11.2, U2.A13 (IO_L4N_T0_D05_14)
unnamed: R22.2, U2.A12 (IO_L4P_T0_D04_14)
unnamed: R13.2, U2.B14 (IO_L5N_T0_D07_14)
unnamed: R12.2, U2.B13 (IO_L5P_T0_D06_14)
unnamed: R14.2, U2.C11 (IO_L6P_T0_FCS_B_14)
unnamed: R33.1, U2.K3 (IO_L16N_T2_34)
unnamed: R32.1, U2.K4 (IO_L16P_T2_34)
unnamed: R35.1, U2.J3 (IO_L17N_T2_34)
unnamed: R34.1, U2.J4 (IO_L17P_T2_34)
unnamed: R36.1, U2.L1 (IO_L18N_T2_34)
unnamed: R46.1, U2.M1 (IO_L18P_T2_34)
unnamed: R47.1, U2.M3 (IO_L19P_T3_34)
unnamed: C16.1, U2.H8 (VREFP_0)
unnamed: R14.1, U3.12 (CA1)
unnamed: R13.1, U3.9 (CA2)
unnamed: R12.1, U3.8 (CA3)
unnamed: R11.1, U3.6 (CA4)
unnamed: R22.1, U3.3 (DPX)
unnamed: R15.1, U3.11 (a)
unnamed: R16.1, U3.7 (b)
unnamed: R17.1, U3.4 (c)
unnamed: R18.1, U3.2 (d)
unnamed: R19.1, U3.1 (e)
unnamed: R20.1, U3.10 (f)
unnamed: R21.1, U3.5 (g)
SYSCLK: U2.G11 (IO_L12P_T1_MRCC_14), X1.3 (OUT)
SYSRES: R45.2, U2.H11 (IO_L13P_T2_MRCC_14)
